# Keil uVision project KI-App.uvproj, settings and files
target App (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429II STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: KI-app_lgd_auto +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_USB_OTG_FS
  c include: ..\src;..\inc;..\gui;..\tool;..\test;..\spec;..\func;..\Config;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\Libraries\STemWinLibrary522\inc;..\..\Libraries\STemWinLibrary522\Lib;..\..\Libraries\STemWinLibrary522\Config;..\..\Utilities\Third_Party\fat_fs1\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x8020000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../src/: stm32fxxx_it.c stm32fxxx_it.h system_stm32f4xx.c stm32f4xx_conf.h
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group Main
    ../src/: REV_HISTORY.txt main.c main.h sys_util.c sys_util.h
  group Func
    ../func/: func_lsi_main.c func_lsi_main.h func_lsi_touch.c func_lsi_touch.h func_mfs_touch.c func_mfs_touch.h func_pmic.c func_pmic.h func_eep.c func_eep.h CRC_Control.c CRC_Control.h func_tpic.c func_tpic.h LX_Semicon.c LX_Semicon.h
  group Tool
    ../src/: Task_USBh.c Task_USBh.h
    ../tool/: task_operation.c task_operation.h task_Measure.c task_Measure.h task_mux_control.c task_mux_control.h task_pc_conn.c task_pc_conn.h
  group Test
    ../test/: task_test.c task_test.h task_open.c task_open.h task_short.c task_short.h task_part.c task_part.h task_func.c task_func.h task_Log.c task_Log.h
  group Spec
    ../spec/: task_spec.c task_spec.h task_spec_define.c task_spec_define.h task_ict_spec_save.c task_ict_spec_save.h task_panel_spec_save.c task_panel_spec_save.h task_data_save.c task_data_save.h task_spec_pc.c task_spec_pc.h task_panel_pc.c task_panel_pc.h task_data_pc.c task_data_pc.h task_pmic.c task_pmic.h task_eep.c task_eep.h
  group LCD
    ../gui/: GUI_Resource.c GUI_Resource.h GUI_Init.c GUI_Init.h GUI_Listview.c GUI_Listview.h GUI_State.c GUI_State.h GUI_MenuButton.c GUI_MenuButton.h GUI_KeyPad.c GUI_KeyPad.h GUI_Sysicon.c GUI_Sysicon.h GUI_Syswin1.c GUI_Syswin1.h GUI_Syswin2.c GUI_Syswin2.h GUI_Syswin3.c GUI_Syswin3.h GUI_Syswin4.c GUI_Syswin4.h
  group HAL
    ../src/: Hal_I2C.c Hal_I2C.h Hal_GPIO.c Hal_GPIO.h Hal_UART.c Hal_UART.h Hal_SPI.c Hal_SPI.h Hal_Timer.c Hal_Timer.h Hal_ADC.c Hal_ADC.h Hal_DAC.c Hal_DAC.h Hal_MCP23S17_IO1.c Hal_MCP23S17_IO1.h Hal_MCP23S17_IO2.c Hal_MCP23S17_IO2.h Hal_MCP23S17_IO3.c Hal_MCP23S17_IO3.h Hal_MCP23S17_IO4.c Hal_MCP23S17_IO4.h Hal_SDRAM.c Hal_SDRAM.h Hal_RTC.c Hal_RTC.h Hal_ADS7846.c Hal_ADS7846.h Hal_USB.c Hal_USB.h
  group HAL_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_i2c.c misc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fmc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_ltdc.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_wwdg.c
    ../../Utilities/Third_Party/fat_fs1/src/: ff.c fattime.c
  group USB_Driver
    ../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group LCD_Lib
    ../../Libraries/STemWinLibrary522/Lib/: STemWin522_CM4_Keil.lib
  group LCD_Cfg
    ../../Libraries/STemWinLibrary522/OS/: GUI_X.c
    ../config/: LCDConf.c GUIConf.c
  group LCD_Header
    ../../Libraries/STemWinLibrary522/inc/: GUI.h BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_Generic.h GUIDRV_Lin.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h HEADER.h HEADER_Private.h
